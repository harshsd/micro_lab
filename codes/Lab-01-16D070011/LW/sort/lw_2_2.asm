Org 00h
ljmp main
org 100H


EXCHANGE:
MOV @R0,B
MOV A,R5
MOV @R1,A
JMP RETURN

main:
;0E, FF, 58, 4A, DF;
;FA, 06, 05, 03, 00
MOV 60H,#00eH
MOV 61H,#0ffH
MOV 62H,#058H
MOV 63H,#04aH
MOV 64H,#0dfH

MOV R0,#60H
MOV R1,#70H
MOV R2,#05H
UP: 
MOV A,@R0
MOV @R1,A
INC R1
INC R0
DJNZ R2, UP

MOV R3,#04H
OUTER:MOV R0,#70H
MOV R1,#71H
MOV R2,#04H
AGAIN:MOV A,@R0
MOV B,@R1
MOV R5,A
CLR C
SUBB A,B
JC SKIP
JMP EXCHANGE
SKIP:INC R0
RETURN:INC R1
DJNZ R2, AGAIN
DJNZ R3, OUTER
LOOP: SJMP LOOP
END